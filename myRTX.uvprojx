# Keil uVision project myRTX.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: myRTX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c MotorControl.h MotorControl.c Serial.h Serial.c Audio.c Audio.h LED.c LED.h common.h
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:Startup 2.5.0
